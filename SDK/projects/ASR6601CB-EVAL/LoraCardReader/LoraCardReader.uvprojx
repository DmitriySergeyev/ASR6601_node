# Keil uVision project LoraCardReader.uvprojx, settings and files
target LoraCardReader (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ESEL ELITTLE
  output: LoraCardReader +hex
  AfterMake: .\utils\genbinary.bat
  group platform
    ../../../platform/system/: system_cm4.c startup_cm4.S printf-stdarg.c
  group drivers
    ../../../drivers/peripheral/src/: tremo_adc.c tremo_bstimer.c tremo_crc.c tremo_dac.c tremo_delay.c tremo_dma.c tremo_flash.c tremo_gpio.c tremo_i2c.c tremo_i2s.c tremo_iwdg.c tremo_lcd.c tremo_lptimer.c tremo_lpuart.c tremo_pwr.c tremo_rcc.c tremo_rtc.c tremo_spi.c tremo_system.c tremo_timer.c tremo_uart.c tremo_wdg.c
  group user
    ./src/: main.c tremo_it.c
  group CardReader
    ./src/CardReader/: CardReader.c CardReader.h
  group device
    ./src/device/: debug.c debug.h HwCardReader.c HwCardReader.h
  group lib
    ../../../drivers/crypto/lib/: libcrypto.a
  group Apps
    ./src/apps/: Apps.h CardReaderApp.c LoRaWanApp.c CardInfoSender.c syslog.c syslog.h Config.c
  group lora/regions
    ../../../lora/mac/region/: Region.c RegionCommon.c RegionEU868.c
  group lora/radio
    ../../../lora/radio/sx126x/: radio.c sx126x.c
    ../../../lora/driver/: sx1262-board.c
  group lora/utils
    ../../../lora/driver/: rtc-board.c utilities.c
    ../../../lora/system/: delay.c timer.c
    ../../../lora/system/crypto/: cmac.c
  group lora/mac
    ../../../lora/mac/: LoRaMac.c LoRaMacClassB.c LoRaMacConfirmQueue.c LoRaMacCrypto.c
